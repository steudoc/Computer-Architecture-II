# Keil uVision project ABI_C+ASM.uvprojx, settings and files
target LandTiger_LPC1768 (release) (6220000::V6.22::ARMCLANG)
  device: LPC1768 NXP
  pack: Keil.LPC1700_DFP.2.7.2
  cpu: IRAM(0x10000000,0x8000) IRAM2(0x2007C000,0x8000) IROM(0x00000000,0x80000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: ABI_C+ASM
  c flags: Optim=2 v6Lang=1 v6LangP=3
  c include: .\Source
  asm include: .\Source
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x2007c000 size 0x8000
  group Source Group 1
    ./Source/: startup_LPC17xx.s main.c ASM_funct.s
    ./: fast_inv_sqrt.s
target SW_Debug (6240000::V6.24::ARMCLANG)
  device: LPC1768 NXP
  pack: Keil.LPC1700_DFP.2.7.2
  cpu: as above
  output: ABI_C+ASM
  c flags: Optim=2 v6Lang=1 v6LangP=3
  c define: SIMULATOR
  c include: .\Source
  asm include: .\Source
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x2007c000 size 0x8000
